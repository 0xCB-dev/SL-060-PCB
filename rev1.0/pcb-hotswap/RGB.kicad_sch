File: rev1.0/pcb-hotswap/RGB.kicad_sch (KiCad schematic)
At the start: 68 parts

Commit message: done
Other:
- moved on the sheet: D58, D59, D60, D61, D62, D63
